# Keil uVision project Demo.uvprojx, settings and files
target stm32f207vc (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32F207VCTx STMicroelectronics
  pack: Keil.STM32F2xx_DFP.2.9.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Demo
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: STM32F2XX,USE_STDPERIPH_DRIVER
  c include: ..\APP\inc;..\Drivers\BSP\inc;..\Drivers\CMSIS\inc;..\Drivers\STM32F2xx_StdPeriph_Driver\inc
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group APP
    ../APP/src/: main.c stm32f2xx_it.c
  group BSP
    ../Drivers/BSP/src/: led.c
  group Core
    ../Drivers/CMSIS/src/: system_stm32f2xx.c
  group Startup
    ../Drivers/CMSIS/startup/: startup_stm32f2xx.s
  group FWLIB
    ../Drivers/STM32F2xx_StdPeriph_Driver/src/: misc.c stm32f2xx_adc.c stm32f2xx_can.c stm32f2xx_crc.c stm32f2xx_cryp.c stm32f2xx_cryp_aes.c stm32f2xx_cryp_des.c stm32f2xx_cryp_tdes.c stm32f2xx_dac.c stm32f2xx_dbgmcu.c stm32f2xx_dcmi.c stm32f2xx_dma.c stm32f2xx_exti.c stm32f2xx_flash.c stm32f2xx_fsmc.c stm32f2xx_gpio.c stm32f2xx_hash.c stm32f2xx_hash_md5.c stm32f2xx_hash_sha1.c stm32f2xx_i2c.c stm32f2xx_iwdg.c stm32f2xx_pwr.c stm32f2xx_rcc.c stm32f2xx_rng.c stm32f2xx_rtc.c stm32f2xx_sdio.c stm32f2xx_spi.c stm32f2xx_syscfg.c stm32f2xx_tim.c stm32f2xx_usart.c stm32f2xx_wwdg.c
  group ReadMe
    ../Doc/: ReadMe.txt
